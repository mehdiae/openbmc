FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:ast2600-dcscm-avenue-city = " \
	file://intel-avenue-city-crb.cfg \
"

