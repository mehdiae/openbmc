RDEPENDS:${PN}-apps:remove:ast2700-fpga = " \
    e2fsprogs-mke2fs \
    ethtool \
    stressapptest \
    nvme-cli \
    iozone3 \
    hdparm \
    "