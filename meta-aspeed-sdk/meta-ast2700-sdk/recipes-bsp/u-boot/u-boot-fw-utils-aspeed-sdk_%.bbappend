FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://fw_env_ast2700_nor.config "
ENV_CONFIG_FILE = "fw_env_ast2700_nor.config"

