RDEPENDS:${PN}-inband:remove = " \
    phosphor-ipmi-ssif \
    "
