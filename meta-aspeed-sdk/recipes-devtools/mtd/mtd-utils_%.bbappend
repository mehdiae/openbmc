FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRCREV:spi-nor-ecc = "71edfe3b5a51ea9a7fac9760804db328ea1ec8a0"
